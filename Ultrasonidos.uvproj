# Keil uVision project Ultrasonidos.uvproj, settings and files
target LPC1768-Jlink (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Ultrasonidos
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./: startup_LPC17xx.s
    C:/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
  group SourceFiles
    ./: Ultrasonidos.c GLCD.c AsciiLib.c
target LPC1768-Simu (ARM-ADS)
  device: LPC1768 NXP
  cpu: as above
  output: Ultrasonidos
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
